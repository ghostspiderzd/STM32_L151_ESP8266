# Keil uVision project STM32L1-M8266WIFI.uvprojx, settings and files
target STM32L-M8266WIFI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L152RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM321-M8266WIFI
  c flags: OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xC
  c include: ..\CORE;..\CORE\STM32L1xx_CMSIS_Device_Include;..\STM32L1xx_HAL_Driver\Inc;..\SYSTEM;..\HARDWARE\LED;..\HARDWARE\KEY;..\M8266WIFI;..\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group CORE
    ../CORE/: startup_stm32l152xc.s
  group HALLIB
    ../STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_rcc.c stm32l1xx_hal_spi.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group M8266WIFI
    ../M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFIDrv_STM32L1xx.lib M8266WIFI_ops.c test_m8266wifi.c
  group USER
    ./: system_stm32l1xx.c main.c uartdriver.c time.c protocol.c stm32l1xx_it.c wifidriver.c switch.c speed.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
